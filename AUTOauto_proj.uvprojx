# Keil uVision project AUTOauto_proj.uvprojx, settings and files
target Aa (5060020::V5.06 (build 20)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AUTOauto_proj
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group app
    ./app/: PWM.c PWM.h main.c Drive.c ring_buffer.h ring_buffer.c sLCD.c sLCD.h USART.c Select.c Echo.h Echo.c Trig.c Trig.h Common.h PIT.c PIT.h Head.c Head.h Select.h IO.c IO.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
